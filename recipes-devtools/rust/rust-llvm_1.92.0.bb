require rust-llvm.inc

# License file checksum needed for do_populate_lic when including a
# Rust app in an image.
LIC_FILES_CHKSUM="file://LICENSE.TXT;md5=1eea00f98e338ab95bd15776ceb4d3be"
