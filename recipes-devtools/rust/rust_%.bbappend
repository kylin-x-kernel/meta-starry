# rust_1.92.0 includes cargo in stage2/bin
# Declare that it provides cargo to satisfy dependencies
PROVIDES:append:class-native = " cargo-native"

