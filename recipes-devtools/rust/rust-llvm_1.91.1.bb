# check src/llvm-project/cmake/modules/LLVMVersion.cmake for llvm version in use
#
LLVM_RELEASE = "21.1.5"
require rust-source-${PV}.inc
require rust-llvm.inc
