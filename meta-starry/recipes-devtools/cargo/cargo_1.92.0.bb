require recipes-devtools/rust/rust-source_${PV}.inc
require recipes-devtools/rust/rust-snapshot_${PV}.inc
require cargo.inc
BBCLASSEXTEND = "native nativesdk"
