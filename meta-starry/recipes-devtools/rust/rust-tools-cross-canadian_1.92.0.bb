require rust-tools-cross-canadian.inc
require rust-source_${PV}.inc
require rust-snapshot_${PV}.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/rust:"

