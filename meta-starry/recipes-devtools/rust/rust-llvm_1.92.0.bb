# check src/llvm-project/llvm/CMakeLists.txt for llvm version in use
#
LLVM_RELEASE = "21.1.5"
require rust-source_${PV}.inc
require rust-llvm.inc

