# Fix missing gettext dependency  
DEPENDS:append:class-native = " gettext-native"
